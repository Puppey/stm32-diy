# Keil uVision project RTOS_LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS_LED +hex
  c flags: Optim=1
  c include: ..\BSP;..\FWlib\inc;..\App;..\OS\uCOS-II\Source;..\OS\uCOS-II\Ports
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../OS/uCOS-II/Source/: os_cfg_r.h
    ../App/: app_cfg.h main.c includes.h LCD1602.c DS1302.c 24C64.c
    ../FWlib/Start files/: cortexm3_macro.s stm32f10x_vector.s
  group Bsp
    ../BSP/: bsp.c
  group uCOS-II/Port
    ../OS/uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    ../OS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group FWlib
    ../FWlib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Readme
    ../: Readme.txt
